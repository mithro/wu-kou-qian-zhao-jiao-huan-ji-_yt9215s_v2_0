# Repository mithro/wu-kou-qian-zhao-jiao-huan-ji-_yt9215s_v2_0 (continued)

## KiCad design kicad/YT9215S-5-port-switch.kicad_pcb (continued)

Parts:
C1: 22nF; C0402; Manufacturer Part 0402B223K500NT; LCSC Part Name 22nF ±10% 50V
C2, C6: 220uF; CAP-SMD_BD6.3-L6.6-W6.6-LS7.4-FD; Manufacturer Part RVT1E221M0607; LCSC Part Name 220uF ±20% 25V
C3, C7: 100nF; C0402; Manufacturer Part CL05B104KO5NNNC; LCSC Part Name 100nF ±10% 16V
C4: 10nF; C0402; Manufacturer Part CL05B103KB5NNNC; LCSC Part Name 10nF ±10% 50V
C5: 22pF; C0402; Manufacturer Part 0402CG220J500NT; LCSC Part Name 22pF ±5% 50V
C8, C11, C12, C13, C28, C37, C38, C41, C43, C51: 10uF; C0805; Manufacturer Part 0805X106K250NT; LCSC Part Name 10uF ±10% 25V
C9, C14, C15, C16, C17, C18, C19, C20, C21, C22, C23, C24, C25, C26, C27, C30, C31, C32, C33, C34, C35, C36, C39, C40, C42, C44, C45: 10nF; C0603; Manufacturer Part 0603B103K500NT; LCSC Part Name 10nF ±10% 50V
C10, C46: 100nF; C0603; Manufacturer Part 0603B104K500NT; LCSC Part Name 100nF ±10% 50V
C29, C47: 1uF; C0603; Manufacturer Part 0603B105K500NT; LCSC Part Name 1uF(105) ±10% 50V
C48: 1nF; C0603; Manufacturer Part 0603B102K500NT; LCSC Part Name 1nF ±10% 50V
C49, C50: 4pF; C0603; Manufacturer Part 0603CG4R0B500NT; LCSC Part Name 4pF 50V ±0.1pF
D1: 1N4148WQ; SOD-123_L2.7-W1.6-LS3.7-RD-1; Manufacturer Part 1N4148WQ; LCSC Part Name 车规级
DC1: DC-005-20A; DC-IN-TH_DC-005-20A; Manufacturer Part DC-005-20A; LCSC Part Name DC-005-20A 内芯2.0mm 全铜
F1: BSMD1206-075-30V; F1206; Manufacturer Part BSMD1206-075-30V; LCSC Part Name 1206 0.75A 30V 佰宏高电压
H1: PZ254V-11-02P; HDR-TH_2P-P2.54-V-M; Manufacturer Part PZ254V-11-02P; LCSC Part Name 2.54mm 1x2P 直插 方针
L1: 4.7uH; IND-SMD_L4.0-W4.0; Manufacturer Part SWPA4030S4R7MT; LCSC Part Name 4.7uH ±20%
L2: 2.2uH; IND-SMD_L4.0-W4.0_SWPA4018S; Manufacturer Part SWPA4018S2R2MT; LCSC Part Name 2.2uH ±20% 3.2A
L3, L4, L5, L6, L7, L8, L9, L10: BLM18KG221SN1D; L0603; Manufacturer Part BLM18KG221SN1D; LCSC Part Name 单路 0603磁珠 阻抗220Ω@100MHz
LED1: NCD0603W1; LED0603-RD; Manufacturer Part NCD0603W1; LCSC Part Name NCD0603W1
R1: 18kΩ; R0402; Manufacturer Part 0402WGF1802TCE; LCSC Part Name 18kΩ ±1% 62.5mW
R2: 10kΩ; R0402; Manufacturer Part 0402WGF1002TCE; LCSC Part Name 10kΩ ±1% 62.5mW
R3, R4: 2kΩ; R0402; Manufacturer Part 0402WGF2001TCE; LCSC Part Name 2kΩ ±1% 62.5mW
R5, R6: 0Ω; R1206; Manufacturer Part RS-06000JT; LCSC Part Name 0Ω ±5% 250mW
R7: 2.49kΩ; R0402; Manufacturer Part RC0402FR-072K49L; LCSC Part Name 厚膜电阻 2.49kΩ ±1% 62.5mW
R8: 150Ω; R0603; Manufacturer Part 0603WAF1500T5E; LCSC Part Name 150Ω ±1% 100mW
R9, R10: 5.1kΩ; R0603; Manufacturer Part 0603WAF5101T5E; LCSC Part Name 5.1kΩ ±1% 100mW
R11, R12, R13, R14: 4.7kΩ; R0603; Manufacturer Part 0603WAF4701T5E; LCSC Part Name 4.7kΩ ±1% 100mW
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8, TP9, TP10, TP12, TP13, TP14, TP15, TP16: TestPoint; Test-Point-0.5mm
TP11: TestPoint; Test-Point-0.5mm_1
U1: MT2492; SOT-23-6_L2.9-W1.6-P0.95-LS2.8-BL; Manufacturer Part MT2492; LCSC Part Name 降压型
U2: RTL8367S-CG; LQFP-128_L14.0-W14.0-P0.40-LS16.0-BL; Manufacturer Part RTL8367S-CG; LCSC Part Name 二层管理5+2端口10/100/1000M交换机控制器
USB1: TYPE-C 6P(040新); USB-C-SMD_TYPE-C-6P; Manufacturer Part TYPE-C 6P(040新); LCSC Part Name Type-C 母座 卧贴 外壳带丝印
X1: -; CRYSTAL-SMD_4P-L2.0-W1.6-BL; Manufacturer Part XRCGB25M000F3M00R0; LCSC Part Name XRCGB25M000F3M00R0

Connections:
3V3: C2.1, C3.2, C4.2, C5.1, D1.1 (K), H1.1, L1.2, L3.1, L4.1, L5.1, L6.1, L7.1, R1.1, R8.1, R11.2, R12.2, R13.2, R14.2, TP1.1; also elsewhere on the board
/P1/DISAUTOLOAD: R11.1, TP14.1, U2.76 (DISAUTOLOAD/GPO45)
/P1/EN_PWRLIGHT: R12.1, U2.73 (EN_PWRLIGHT/GPO42)
/P1/EN_SWR: R14.1, TP16.1, U2.60 (EN_SWR)
/P1/NRST: C51.2, D1.2 (A), R13.1, TP15.1, U2.86 (nRESET)
/P1/PLLGND: C47.1, C48.1, L10.2, TP13.1, U2.115 (PLLGND)
/P1/PLLVDDL: C47.2, C48.2, L9.2, TP12.1, U2.114 (PLLVDDL)
/P1/XTAL_IN: C50.2, U2.84 (XTALI), X1.3 (OSC2)
/P1/XTAL_OUT: C49.2, U2.83 (XTALO), X1.1 (OSC1)
AVDDH: C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, L3.2, TP4.1, U2.11 (AVDDH), U2.17 (AVDDH), U2.21 (AVDDH), U2.33 (AVDDH), U2.82 (AVDDH), U2.90 (AVDDH), U2.102 (AVDDH), U2.116 (AVDDH), U2.128 (AVDDH)
AVDDL: C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C46.2, L9.1, R5.2, TP5.1, U2.6 (AVDDL), U2.14 (AVDDL), U2.27 (AVDDL), U2.95 (AVDDL), U2.108 (AVDDL), U2.122 (AVDDL)
DVDDIO: C41.2, C42.2, L6.2, TP9.1, U2.67 (DVDDIO)
DVDDIO_2: C37.2, C38.2, C39.2, C40.2, L5.2, TP8.1, U2.42 (DVDDIO_2), U2.59 (DVDDIO_2)
DVDDL: C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, R6.2, TP7.1, U2.20 (DVDDL), U2.58 (DVDDL), U2.69 (DVDDL)
GND: C2.2, C3.1, C4.1, C6.2, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.1, C27.1, C28.1, C29.1, C30.1, C31.1, C32.1, C33.1, C34.1, C35.1, C36.1, C37.1, C38.1, C39.1, C40.1, C41.1, C42.1, C43.1, C44.1, C45.1, C46.1, C49.1, C50.1, C51.1, DC1.2, DC1.3, H1.2, L10.1, LED1.1 (-), R3.2, R7.1, R9.2, R10.1, U1.2 (GND), U2.1 (GND), U2.12 (AGND), U2.18 (GND), U2.24 (GND), U2.32 (GND), U2.34 (SGND), U2.40 (SGND), U2.43 (GND), U2.44 (GND), U2.57 (GND), U2.61 (GND_SWR), U2.62 (GND_SWR), U2.68 (GND), U2.85 (GND), U2.89 (GND), U2.96 (GND), U2.99 (GND), U2.105 (GND), U2.111 (GND), U2.119 (GND), U2.125 (GND), USB1.1 (SHELL), USB1.2 (SHELL), USB1.A12 (GND), USB1.B12 (GND), X1.2 (GND), X1.4 (GND); also elsewhere on the board
HV_SWR: C28.2, C29.2, C30.2, L4.2, TP6.1, U2.65 (HV_SWR), U2.66 (HV_SWR)
unnamed: L2.1, U2.63 (LX), U2.64 (LX)
unnamed: LED1.2 (+), R8.2
unnamed: R3.1, R4.2
unnamed: C1.1, U1.1 (BS)
unnamed: R2.2, U1.4 (EN)
unnamed: C5.2, R1.2, R4.1, U1.3 (FB)
unnamed: C1.2, L1.1, U1.6 (SW)
unnamed: R7.2, U2.13 (MDIREF)
unnamed: R9.1, USB1.A5 (CC1)
unnamed: R10.2, USB1.B5 (CC2)
P0MDIA_N: U2.92 (P0MDIAN); also elsewhere on the board
P0MDIA_P: U2.91 (P0MDIAP); also elsewhere on the board
P0MDIB_N: U2.94 (P0MDIBN); also elsewhere on the board
P0MDIB_P: U2.93 (P0MDIBP); also elsewhere on the board
P0MDIC_N: U2.98 (P0MDICN); also elsewhere on the board
P0MDIC_P: U2.97 (P0MDICP); also elsewhere on the board
P0MDID_N: U2.101 (P0MDIDN); also elsewhere on the board
P0MDID_P: U2.100 (P0MDIDP); also elsewhere on the board
P0_LED0: U2.81 (SMI_SEL/LED_CK/LAN0LED0/GPO52); also elsewhere on the board
P0_LED1: U2.80 (LED_DA/LAN0LED1/GPO51); also elsewhere on the board
P1MDIA_N: U2.104 (P1MDIAN); also elsewhere on the board
P1MDIA_P: U2.103 (P1MDIAP); also elsewhere on the board
P1MDIB_N: U2.107 (P1MDIBN); also elsewhere on the board
P1MDIB_P: U2.106 (P1MDIBP); also elsewhere on the board
P1MDIC_N: U2.110 (P1MDICN); also elsewhere on the board
P1MDIC_P: U2.109 (P1MDICP); also elsewhere on the board
P1MDID_N: U2.113 (P1MDIDN); also elsewhere on the board
P1MDID_P: U2.112 (P1MDIDP); also elsewhere on the board
P1_LED0: U2.79 (EN_PHY/LAN1LED0/GPO50); also elsewhere on the board
P1_LED1: U2.78 (LAN1LED1/GPIO49); also elsewhere on the board
P2MDIA_N: U2.118 (P2MDIAN); also elsewhere on the board
P2MDIA_P: U2.117 (P2MDIAP); also elsewhere on the board
P2MDIB_N: U2.121 (P2MDIBN); also elsewhere on the board
P2MDIB_P: U2.120 (P2MDIBP); also elsewhere on the board
P2MDIC_N: U2.124 (P2MDICN); also elsewhere on the board
P2MDIC_P: U2.123 (P2MDICP); also elsewhere on the board
P2MDID_N: U2.127 (P2MDIDN); also elsewhere on the board
P2MDID_P: U2.126 (P2MDIDP); also elsewhere on the board
P2_LED0: U2.75 (DIS_8051/LAN2LED0/GPO44); also elsewhere on the board
P2_LED1: U2.77 (LAN2LED1/GPIO46); also elsewhere on the board
P3MDIA_N: U2.3 (P3MDIAN); also elsewhere on the board
P3MDIA_P: U2.2 (P3MDIAP); also elsewhere on the board
P3MDIB_N: U2.5 (P3MDIBN); also elsewhere on the board
P3MDIB_P: U2.4 (P3MDIBP); also elsewhere on the board
P3MDIC_N: U2.8 (P3MDICN); also elsewhere on the board
P3MDIC_P: U2.7 (P3MDICP); also elsewhere on the board
P3MDID_N: U2.10 (P3MDIDN); also elsewhere on the board
P3MDID_P: U2.9 (P3MDIDP); also elsewhere on the board
P3_LED0: U2.74 (EN_SPIF/LAN3LED0/GPO43); also elsewhere on the board
P3_LED1: U2.72 (LAN3LED1/GPIO41); also elsewhere on the board
P4MDIA_N: U2.23 (P4MDIAN); also elsewhere on the board
P4MDIA_P: U2.22 (P4MDIAP); also elsewhere on the board
P4MDIB_N: U2.26 (P4MDIBN); also elsewhere on the board
P4MDIB_P: U2.25 (P4MDIBP); also elsewhere on the board
P4MDIC_N: U2.29 (P4MDICN); also elsewhere on the board
P4MDIC_P: U2.28 (P4MDICP); also elsewhere on the board
P4MDID_N: U2.31 (P4MDIDN); also elsewhere on the board
P4MDID_P: U2.30 (P4MDIDP); also elsewhere on the board
P4_LED0: U2.70 (EEPROM_MOD/LAN4LED0/GPO39); also elsewhere on the board
P4_LED1: U2.71 (LAN4LED1/GPIO40); also elsewhere on the board
SVDDH: C43.2, C44.2, L7.2, TP10.1, U2.41 (SVDDH)
SVDDL: C45.2, L8.2, TP11.1, U2.37 (SVDDL)
VBUS: C6.1, C7.2, F1.2, R2.1, TP2.1, U1.5 (IN)
VDDL: C8.2, C9.2, C10.2, L2.2, L8.1, R5.1, R6.1, TP3.1
V_BUS: DC1.1, F1.1, USB1.A9 (VBUS), USB1.B9 (VBUS)

Notes on the sheet:
保险丝
启用内部1.1V DC-DC输出
0.6*(1+18K/4K)=3.3
通电时刻灯全亮
指示灯
无需配置固件
输入接口
MT2492:INPUT 4.5-16V；2A
外接风扇

Board: 2 copper layers, 100.0 x 65.0 mm, 135 parts (61 on the bottom side), 96 nets.

Other parts of the board:
EP1: U2 exposed pad; Pad_e346
MH1, MH2, MH3, MH4: MountingHole_3.2mm

Their connections:
GND: EP1.129; also elsewhere on the board

File bom/bom.csv:

No.,Quantity,Comment,Designator,Footprint,Value,Manufacturer Part,Manufacturer,Supplier Part,Supplier
1,1,22nF,C1,C0402,22nF,0402B223K500NT,FH(风华),C1532,LCSC
2,2,220uF,"C2,C6",CAP-SMD_BD6.3-L6.6-W6.6-LS7.4-FD,220uF,RVT1E221M0607,ROQANG(容强),C2918361,LCSC
3,2,100nF,"C3,C7",C0402,100nF,CL05B104KO5NNNC,SAMSUNG(三星),C1525,LCSC
4,1,10nF,C4,C0402,10nF,CL05B103KB5NNNC,SAMSUNG(三星),C15195,LCSC
5,1,22pF,C5,C0402,22pF,0402CG220J500NT,FH(风华),C1555,LCSC
6,10,10uF,"C8,C11,C12,C13,C28,C37,C38,C41,C43,C51",C0805,10uF,0805X106K250NT,FH(风华),C40894,LCSC
7,27,10nF,"C9,C14,C15,C16,C17,C18,C19,C20,C21,C22,C23,C24,C25,C26,C27,C30,C31,C32,C33,C34,C35,C36,C39,C40,C42,C44,C45",C0603,10nF,0603B103K500NT,FH(风华),C57112,LCSC
8,2,100nF,"C10,C46",C0603,100nF,0603B104K500NT,FH(风华),C30926,LCSC
9,2,1uF,"C29,C47",C0603,1uF,0603B105K500NT,FH(风华),C90540,LCSC
10,1,1nF,C48,C0603,1nF,0603B102K500NT,FH(风华),C44369,LCSC
11,2,4pF,"C49,C50",C0603,4pF,0603CG4R0B500NT,FH(风华),C507053,LCSC
12,5,100nF,"C52,C53,C54,C55,C56",C0402,100nF,FN15X104K250PNG,PSA(信昌电陶),C525225,LCSC
13,1,1N4148WQ,D1,SOD-123_L2.7-W1.6-LS3.7-RD-1,,1N4148WQ,YANGJIE(扬杰),C2942441,LCSC
14,1,DC-005-20A,DC1,DC-IN-TH_DC-005-20A,,DC-005-20A,韩国韩荣,C136744,LCSC
15,1,BSMD1206-075-30V,F1,F1206,,BSMD1206-075-30V,BHFUSE(佰宏),C976305,LCSC
16,1,PZ254V-11-02P,H1,HDR-TH_2P-P2.54-V-M,,PZ254V-11-02P,XFCN(兴飞),C492401,LCSC
17,1,4.7uH,L1,IND-SMD_L4.0-W4.0,4.7uH,SWPA4030S4R7MT,Sunlord(顺络),C57269,LCSC
18,1,2.2uH,L2,IND-SMD_L4.0-W4.0_SWPA4018S,2.2uH,SWPA4018S2R2MT,Sunlord(顺络),C50543,LCSC
19,8,BLM18KG221SN1D,"L3,L4,L5,L6,L7,L8,L9,L10",L0603,,BLM18KG221SN1D,muRata(村田),C88980,LCSC
20,1,NCD0603W1,LED1,LED0603-RD,,NCD0603W1,国星光电,C84265,LCSC
21,1,18kΩ,R1,R0402,18kΩ,0402WGF1802TCE,UNI-ROYAL(厚声),C25762,LCSC
22,1,10kΩ,R2,R0402,10kΩ,0402WGF1002TCE,UNI-ROYAL(厚声),C25744,LCSC
23,2,2kΩ,"R3,R4",R0402,2kΩ,0402WGF2001TCE,UNI-ROYAL(厚声),C4109,LCSC
24,2,0Ω,"R5,R6",R1206,0Ω,RS-06000JT,FH(风华),C115323,LCSC
25,1,2.49kΩ,R7,R0402,2.49kΩ,RC0402FR-072K49L,YAGEO(国巨),C145071,LCSC
26,1,150Ω,R8,R0603,150Ω,0603WAF1500T5E,UNI-ROYAL(厚声),C22808,LCSC
27,2,5.1kΩ,"R9,R10",R0603,5.1kΩ,0603WAF5101T5E,UNI-ROYAL(厚声),C23186,LCSC
28,4,4.7kΩ,"R11,R12,R13,R14",R0603,4.7kΩ,0603WAF4701T5E,UNI-ROYAL(厚声),C23162,LCSC
29,10,4.7kΩ,"R15,R16,R17,R18,R19,R20,R27,R28,R29,R30",R0402,4.7kΩ,0402WGF4701TCE,UNI-ROYAL(厚声),C25900,LCSC
30,10,470Ω,"R21,R22,R23,R24,R25,R26,R31,R32,R33,R34",R0402,470Ω,0402WGF4700TCE,UNI-ROYAL(厚声),C25117,LCSC
31,5,HR911130A,"RJ1,RJ2,RJ3,RJ4,RJ5",RJ45-TH_HR911130A,,HR911130A,HANRUN(汉仁),C54408,LCSC
32,16,Test-Point,"TP1,TP2,TP3,TP4,TP5,TP6,TP7,TP8,TP9,TP10,TP11,TP12,TP13,TP14,TP15,TP16",Test-Point-0.5mm,,,,,
33,1,MT2492,U1,SOT-23-6_L2.9-W1.6-P0.95-LS2.8-BL,,MT2492,西安航天民芯,C89358,LCSC
34,1,RTL8367S-CG,U2,LQFP-128_L14.0-W14.0-P0.40-LS16.0-BL,,RTL8367S-CG,REALTEK(瑞昱),C2760849,LCSC
35,1,TYPE-C 6P(040新),USB1,USB-C-SMD_TYPE-C-6P,,TYPE-C 6P(040新),SHOU HAN(首韩),C2887422,LCSC
36,1,-,X1,CRYSTAL-SMD_4P-L2.0-W1.6-BL,-,XRCGB25M000F3M00R0,muRata(村田),C127893,LCSC
